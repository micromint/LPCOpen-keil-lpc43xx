# IAR project freertos_blinky_m0.ewp, settings and files
configuration spifi_bambino (ARM)
  General.OGChipSelectEditMenu: LPC4330_M0 NXP LPC4330_M0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0; OS_FREE_RTOS
  ICCARM.CCDiagSuppress: Pa050, Pa082
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx_m0app; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common; ../../../../examples/dualcore_43xx/common; ..\..\..\..\..\..\software\freertos\freertos\Source\include; ..\..\..\..\..\..\software\freertos\freertos\Source\portable\IAR\ARM_CM0
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M0
  AARM.AUserIncludes: ../../../../examples/dualcore_43xx/common
  OBJCOPY.OOCOutputFile: sa_blinky_m0.srec
  ILINK.IlinkOutputFile: freertos_blinky_m0.out
  ILINK.IlinkIcfFile: ..\..\..\..\examples\dualcore_43xx\common\linker_scripts\m0_spifi.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/dualcore_43xx/blinky/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/iar_output/bambino_m0/Exe/: lib_lpc_board_bambino_m0.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_m0_lib/Exe/: lib_lpc_chip_43xx_m0.a
  group src
    ../../../../examples/dualcore_43xx/blinky/: dualcore_blinky.c
    ../../../../examples/dualcore_43xx/common/startup_code/: iar_startup_lpc43xx_m0.S
    ../../../../examples/dualcore_43xx/common/: ipc_example.c ipc_msg.c m0_img_ldr.c main.c
    ../../../../startup_code/: sysinit.c
  group src/freertos
    ../../../../../../software/freertos/freertoslpc/: FreeRTOS_lpc43xx_m0_Tick.c FreeRTOSCommonHooks.c
    ../../../../../../software/freertos/freertos/Source/portable/MemMang/: heap_3.c
    ../../../../../../software/freertos/freertos/Source/: list.c queue.c tasks.c
    ../../../../../../software/freertos/freertos/Source/portable/IAR/ARM_CM0/: port.c portasm.s
