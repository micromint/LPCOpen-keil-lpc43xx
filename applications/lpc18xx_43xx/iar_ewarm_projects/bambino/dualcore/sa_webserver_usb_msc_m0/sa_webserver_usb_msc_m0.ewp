# IAR project sa_webserver_usb_msc_m0.ewp, settings and files
configuration spifi_bambino (ARM)
  General.OGChipSelectEditMenu: LPC4330_M0 NXP LPC4330_M0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M0; EXAMPLE_LWIP; EXAMPLE_USB_DEVICE
  ICCARM.CCDiagSuppress: Pa050, Pa082
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx_m0app; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common; ../../../../examples/dualcore_43xx/common; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\examples\dualcore_43xx\lwip\webserver\configs; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc; ..\..\..\..\examples\dualcore_43xx\usbd_rom\msc_ram\configs; ..\..\..\..\..\..\software\lpc_core\lpc_chip\usbd_rom
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M0
  OBJCOPY.OOCOutputFile: sa_blinky_m0.srec
  ILINK.IlinkOutputFile: sa_webserver_usb_msc_m0.out
  ILINK.IlinkIcfFile: ..\..\..\..\examples\dualcore_43xx\common\linker_scripts\m0_spifi.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/dualcore_43xx/usbd_rom/msc_ram/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/iar_output/bambino_m0/Exe/: lib_lpc_board_bambino_m0.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_m0_lib/Exe/: lib_lpc_chip_43xx_m0.a
  group src
    ../../../../examples/dualcore_43xx/blinky/: dualcore_blinky.c
    ../../../../examples/dualcore_43xx/lwip/webserver/: dualcore_webserver.c httpd.c lwip_fs.c
    ../../../../examples/dualcore_43xx/common/startup_code/: iar_startup_lpc43xx_m0.S
    ../../../../examples/dualcore_43xx/common/: ipc_example.c ipc_msg.c m0_img_ldr.c main.c
    ../../../../startup_code/: sysinit.c
  group src/fatfs
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../../software/filesystems/fatfslpc/: fs_mem.c rtc.c
  group src/lwip
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c ethernetif.c
    ../../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc18xx_43xx_systick_arch.c lpc_debug.c
  group src/usb_msc
    ../../../../examples/dualcore_43xx/usbd_rom/msc_ram/: msc_desc.c msc_main.c msc_ram.c ramdisk.c
