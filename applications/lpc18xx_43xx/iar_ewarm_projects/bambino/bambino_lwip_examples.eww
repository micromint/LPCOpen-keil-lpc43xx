<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\lib_lpc_chip_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino\lib_lpc_board_bambino.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lwip\sa_tpcecho\sa_tcpecho.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lwip\freertos_tcpecho\freertos_tcpecho.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lwip\sa_webserver\sa_webserver.ewp</path>
  </project>
  <batchBuild/>
</workspace>


