# IAR project usbhost_msc.ewp, settings and files
configuration spifi_bambino (ARM)
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4; __LPC43XX__; USB_HOST_ONLY
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../LPCUSBlib/lpcusblib_MassStorageHost; ../../../../../../software/lpc_core/lpc_board/board_common; ../../../../../../software/LPCUSBLib/Drivers/USB; ../../../../../../software/filesystems/fatfs/src; ../../../../../../software/filesystems/fatfslpc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: periph_blinky.srec
  ILINK.IlinkOutputFile: usbhost_msc.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\lpc18xx_43xx_ldscript_spifi.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/iar_output/bambino/Exe/: lib_lpc_board_bambino.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_lib/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s sysinit.c
    ../../../../../LPCUSBlib/lpcusblib_MassStorageHost/: MassStorageHost.c
  group src/fatfs
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../../software/filesystems/fatfslpc/: fs_usb.c rtc.c
  group src/lpcusblib
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/: ConfigDescriptor.c Host.c HostStandardReq.c Pipe.c PipeStream.c USBController.c USBMemory.c USBTask.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/EHCI/: EHCI.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HAL/LPC18XX/: HAL_LPC18xx.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Core/HCD/: HCD.c
    ../../../../../../software/LPCUSBLib/Drivers/USB/Class/Host/: MassStorageClassHost.c
