# IAR project periph_sdmmc.ewp, settings and files
configuration spifi_bambino (ARM)
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common; ../../../../../../software/filesystems/fatfs/src; ../../../../../../software/filesystems/fatfslpc; ../../../../examples/periph/periph_sdmmc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: periph_sdmmc.srec
  ILINK.IlinkOutputFile: periph_sdmmc.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\lpc18xx_43xx_ldscript_spifi.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/periph/periph_sdmmc/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/iar_output/bambino/Exe/: lib_lpc_board_bambino.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_lib/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../../software/filesystems/fatfslpc/: fs_mci.c rtc.c
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s sysinit.c
    ../../../../examples/periph/periph_sdmmc/: sdmmc.c
