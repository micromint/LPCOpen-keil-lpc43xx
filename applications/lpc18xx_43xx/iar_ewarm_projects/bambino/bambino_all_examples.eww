<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\lib_lpc_chip_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino\lib_lpc_board_bambino.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\freertos\freertos_blinky\freertos_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_atimer\periph_atimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_blinky\periph_blinky.ewp</path>
  </project>  
  <project>
    <path>$WS_DIR$\periph\periph_i2cm_interrupt\periph_i2cm_interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2cm_polling\periph_i2cm_polling.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_timers\periph_timers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_ccan\periph_ccan.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_ethernet\periph_ethernet.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_grouped_int\periph_grouped_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2c\periph_i2c.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_i2s\periph_i2s.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_pinint\periph_pinint.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_ritimer\periph_ritimer.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_rtc\periph_rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_sdmmc\periph_sdmmc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_ssp\periph_ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_systick\periph_systick.ewp</path>
  </project>  
  <project>
    <path>$WS_DIR$\periph\periph_uart\periph_uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_uart_rb\periph_uart_rb.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\periph\periph_watchdog\periph_watchdog.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lwip\sa_tpcecho\sa_tcpecho.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lwip\freertos_tcpecho\freertos_tcpecho.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lwip\sa_webserver\sa_webserver.ewp</path>
  </project>
  <batchBuild/>
</workspace>


