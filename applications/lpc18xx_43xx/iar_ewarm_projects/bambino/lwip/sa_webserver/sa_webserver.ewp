# IAR project sa_webserver.ewp, settings and files
configuration spifi_bambino (ARM)
  General.OGChipSelectEditMenu: LPC4330_M4 NXP LPC4330_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: CORE_M4
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/config_43xx; ../../../../../../software/lpc_core/lpc_chip/chip_common; ../../../../../../software/CMSIS/CMSIS/Include; ../../../../../../software/lpc_core/lpc_board/board_common; ..\..\..\..\..\..\software\lwip\lpclwip; ..\..\..\..\..\..\software\lwip\lwip\src\include; ..\..\..\..\..\..\software\lwip\lwip\src\include\ipv4; ..\..\..\..\examples\lwip\webserver\configs; ..\..\..\..\..\..\software\filesystems\fatfs\src; ..\..\..\..\..\..\software\filesystems\fatfslpc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: CORE_M4
  OBJCOPY.OOCOutputFile: periph_blinky.srec
  ILINK.IlinkOutputFile: periph_blinky.out
  ILINK.IlinkIcfFile: ..\..\..\..\tool_configs\iar_linker_scripts\lpc18xx_43xx_spifi_heap.icf
  ILINK.IlinkProgramEntryLabel: Reset_Handler
  group (top)
    ../../../../examples/lwip/webserver/: readme.txt
  group lib
    ../../../../../../software/lpc_core/lpc_board/boards_43xx/bambino/iar_output/bambino/Exe/: lib_lpc_board_bambino.a
    ../../../../../../software/lpc_core/lpc_chip/chip_18xx_43xx/iar_output/chip_43xx_lib/Exe/: lib_lpc_chip_43xx.a
  group src
    ../../../../../../software/filesystems/fatfs/src/: ff.c
    ../../../../../../software/filesystems/fatfslpc/: fs_mci.c rtc.c
    ../../../../examples/lwip/webserver/: httpd.c lwip_fs.c webserver.c
    ../../../../startup_code/: iar_startup_lpc18xx43xx.s sysinit.c
  group src/lwip
    ../../../../../../software/lwip/lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../../../../../software/lwip/lwip/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../../../../../../software/lwip/lwip/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
    ../../../../../../software/lwip/lwip/src/netif/: etharp.c ethernetif.c
    ../../../../../../software/lwip/lpclwip/arch/: lpc18xx_43xx_emac.c lpc18xx_43xx_systick_arch.c lpc_debug.c
