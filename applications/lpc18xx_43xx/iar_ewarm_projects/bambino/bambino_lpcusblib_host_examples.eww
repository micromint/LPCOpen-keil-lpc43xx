<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\lib_lpc_chip_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino\lib_lpc_board_bambino.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lpcusblib_host\usbhost_audioout\usbhost_audioout.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lpcusblib_host\usbhost_keyboard\usbhost_keyboard.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\lpcusblib_host\usbhost_msc\usbhost_msc.ewp</path>
  </project>
  <batchBuild/>
</workspace>


