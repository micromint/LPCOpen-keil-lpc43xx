<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\lib_lpc_chip_43xx.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_chip\chip_18xx_43xx\lib_lpc_chip_43xx_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino\lib_lpc_board_bambino.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\..\..\software\lpc_core\lpc_board\boards_43xx\bambino\lib_lpc_board_bambino_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\sa_blinky\sa_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\sa_blinky_m0\sa_blinky_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\sa_usbd_msc\sa_usbd_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\sa_usbd_msc_m0\sa_usbd_msc_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\sa_webserver\sa_webserver.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\sa_webserver_m0\sa_webserver_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\sa_webserver_usb_msc\sa_webserver_usb_msc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\sa_webserver_usb_msc_m0\sa_webserver_usb_msc_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\freertos_blinky\freertos_blinky.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\freertos_blinky_m0\freertos_blinky_m0.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\freertos_webserver\freertos_webserver.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\dualcore\freertos_webserver_m0\freertos_webserver_m0.ewp</path>
  </project>
  <batchBuild/>
</workspace>


